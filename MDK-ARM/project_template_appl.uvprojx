# Keil uVision project project_template_appl.uvprojx, settings and files
target project_template_appl (6070000::V6.7::.\ARMCLANG)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project_template_appl
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\hodea-stm32f0-vpkg\CMSIS\Include;..\hodea-stm32f0-vpkg\CMSIS\Device\ST\STM32F0xx\Include;..\hodea-lib;..\share
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../appl/: system_stm32f0xx.cpp main.cpp
    ../appl/arm/: startup_stm32f091xc.s bootloader_binary.s
    ../share/: boot_appl_if.cpp
    ../hodea-lib/hodea/rte/: setup.cpp
    ../hodea-lib/hodea/device/stm32/: retarget_stdout_uart.cpp
